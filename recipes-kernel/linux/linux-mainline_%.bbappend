FILESEXTRAPATHS_prepend := "${THISDIR}/linux-mainline/files:"

SRC_URI += "file://defconfig.cfg"
